# Keil uVision project SP400-IAP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SP400-IAP
  BeforeMake: ..\MDK\Version.exe
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Source\CMSIS;..\Source\CMSIS\startup;..\Source\FATFS;..\Source\FATFS\option;..\Source\FWlib\inc;..\Source\GUI;..\Source\IAP;..\Source\SP400-IAP;..\Source\SYSTEM;..\Source\WIFI;..\MDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Source/CMSIS/startup/: startup_stm32f10x_hd.s
    ../Source/CMSIS/: system_stm32f10x.c core_cm3.c
  group FATFS
    ../Source/FATFS/: diskio.c ff.c sdio_sdcard.c
  group FWlib
    ../Source/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group GUI
    ../Source/GUI/: lcd.c
  group FLASH
    ../Source/IAP/: flash_hal.c flashload.c
  group SP400-IAP
    ../Source/SP400-IAP/: main.c Process.c Ymodel.c common.c download.c
  group SYSTEM
    ../Source/SYSTEM/: DELAY.c stm32f10x_it.c crc16.c
  group WIFI
    ../Source/WIFI/: EMSP.c EMSP_API.c EMW_hal.c
